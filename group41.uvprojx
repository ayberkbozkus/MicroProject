# Keil uVision project group41.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: group41
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ../: ProgramTemplate.s
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
